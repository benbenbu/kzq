# Keil uVision project KZQ.uvproj, settings and files
target KZQ (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: KZQ
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver\inc;..\Mdk;..\User\inc;..\Modbus;..\Driver\font
  group User
    ../User/src/: system.c main.c lcd_test.c
  group Driver
    ../Driver/src/: lcd.c bsp.c delay.c fm31256.c time.c uart.c
  group Modbus
    ../Modbus/: modbus.c
  group Font
    ../Driver/font/: font_date.c
